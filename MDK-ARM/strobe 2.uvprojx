# Keil uVision project strobe 2.uvprojx, settings and files
target strobe 2 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F051C6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: strobe 2
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F051x8
  c misc: --C99
  c include: ../Inc;  ../Drivers/STM32F0xx_HAL_Driver/Inc;  ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;  ../Drivers/CMSIS/Device/ST/STM32F0xx/Include;  ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_i2c.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_tim.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Application/User
    ../Src/: main.c stm32f0xx_hal_msp.c stm32f0xx_it.c
  group Application/MDK-ARM
    ./: startup_stm32f051x8.s
software components: CMSIS:CORE 4.1.0
